options:
  parameters:
    author: Chris Thompson VE2TCP
    description: Based on the Langstone radio by G4EML
    generate_options: qt_gui
    id: arex_lang_trx_pluto
    output_language: python
    title: AREX GW Demonstration
  states: {}

blocks:
- name: AFGain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: AMMIC
  id: variable
  parameters:
    value: '5'
  states: {}
- name: CTCSS
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FFT_SEL
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FMMIC
  id: variable
  parameters:
    value: '1'
  states: {}
- name: KEY
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: MicGain
  id: variable
  parameters:
    value: '5.0'
  states: {}
- name: PTT
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: RxOffset
  id: variable
  parameters:
    value: '90000'
  states: {}
- name: Rx_Filt_High
  id: variable
  parameters:
    value: '7500'
  states: {}
- name: Rx_Filt_Low
  id: variable
  parameters:
    value: '-7500'
  states: {}
- name: Rx_Gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: Rx_LO
  id: variable
  parameters:
    value: '5659900000'
  states: {}
- name: Rx_Mode
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Rx_Monitor
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: Rx_Mute
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: ToneBurst
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: Tx_Filt_High
  id: variable
  parameters:
    value: '7500'
  states: {}
- name: Tx_Filt_Low
  id: variable
  parameters:
    value: '-7500'
  states: {}
- name: Tx_Gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Tx_LO
  id: variable
  parameters:
    comment: |-
      TX Freq of 3483400000 will be 10.4502 GHz 
      on third harmonic.

      Transmit on 700200000 to calibrate.
    value: '3483400000'
  states: {}
- name: Tx_Mode
  id: variable
  parameters:
    value: '4'
  states: {}
- name: alsa_audio_sink
  id: variable
  parameters:
    value: '"plughw:3,0,0"'
  states: {}
- name: alsa_audio_source
  id: variable
  parameters:
    value: '"plughw:3,0,1"'
  states: {}
- name: rx_mag_level
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    comment: Sample the received command signal every 10ms
    function_name: level
    poll_rate: '100'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: rx_mag_level
    type: int
    value: rx_mag_level
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '5e-7'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '1000'
    reference: '0.1'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1'
    max_dev: '5000'
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '1.9635'
    min_freq: '-1.9635'
    w: '0.02'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '0.99'
    lo: '-0.99'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: 1.0*ToneBurst
    freq: '1750'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: 0.15 * (CTCSS >0)
    freq: CTCSS/10.0
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: alsa_audio_sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: '"plughw:1,0"'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: alsa_audio_source
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: Rx_Filt_High
    low_cutoff_freq: Rx_Filt_Low
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: Tx_Filt_High
    low_cutoff_freq: Tx_Filt_Low
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '10'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: (0.5 * int(Tx_Mode==5)) + int(Tx_Mode==2) +int(Tx_Mode==3)
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '(MicGain)*(int(Tx_Mode==0)) + (MicGain)*(int(Tx_Mode==1)) + (AMMIC/10.0)*(int(Tx_Mode==5)) '
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: FMMIC/5.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: (AFGain/100.0) *  (not Rx_Mute)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Rx_Monitor
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Rx_Mode<4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (Rx_Mode==4) * 0.2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Rx_Mode==5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 + (Rx_Mode==5)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: Tx_Mode==4
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: (Tx_Mode < 4) or (Tx_Mode==5)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_mute_xx_0_0_0
  id: blocks_mute_xx
  parameters:
    mute: (not PTT) or (Tx_Mode==2 and not KEY) or (Tx_Mode==3 and not KEY)
    type: complex
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: RxOffset
    decim: '11'
    samp_rate: '528000'
    taps: firdes.low_pass(1,529200,23000,2000)
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: Tx_Gain
    bandwidth: '20000000'
    buffer_size: '0x800'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: Tx_LO
    samplerate: '528000'
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x800'
    filter_source: '''Auto'''
    frequency: Rx_LO
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '528000'
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '528000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"RX"'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '48000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"IF"'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    type: float
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '11'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_agc3_xx_0, '0', blocks_complex_to_real_0_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_3, '0']
- [analog_pll_carriertracking_cc_0, '0', band_pass_filter_0, '0']
- [analog_rail_ff_0, '0', band_pass_filter_1, '0']
- [analog_rail_ff_0_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [band_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_mute_xx_0_0_0, '0']
- [band_pass_filter_1, '0', blocks_add_xx_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', analog_rail_ff_0_0, '0']
- [blocks_add_xx_0, '0', analog_rail_ff_0, '0']
- [blocks_add_xx_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_1_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_2, '0', band_pass_filter_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_2_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_2_1_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc3_xx_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_2_1, '0', blocks_add_xx_1_0, '1']
- [blocks_multiply_const_vxx_2_1_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_add_xx_2, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_mute_xx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
