options:
  parameters:
    author: Chris Thompson VE2TCP
    category: Custom
    copyright: 2024 ARISS
    description: AREX Gateway Demonstration of full duplex radio
    generate_options: no_gui
    id: arex_gw_pluto
    output_language: python
    realtime_scheduling: '1'
    title: AREX Gateway Pluto SDR
  states: {}

blocks:
- name: PTT
  id: variable
  parameters:
    value: '1'
  states: {}
- name: audio_sample_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: tx_fm_mic_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_mode
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '144000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_sample_rate
    fh: '-1'
    max_dev: 5e3
    quad_rate: '576000'
    tau: '75e-6'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: rx_audio_device
    samp_rate: audio_sample_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: tx_audio_device
    samp_rate: audio_sample_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '10'
    samp_rate: audio_sample_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_fm_mic_gain/10
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_mode==4
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: not PTT
    type: complex
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '1'
  states: {}
- name: fm_station
  id: parameter
  parameters:
    label: FM station
    type: intx
    value: '145990000'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '437800000'
    samplerate: '576000'
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x20000'
    filter_source: '''Auto'''
    frequency: fm_station
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: uri
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '4'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: '576000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: fm_station
    fftsize: '1024'
    name: Receive Signal
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: audio_sample_rate
    fc: '0'
    fftsize: '1024'
    name: Audio
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: fm_station
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: rx_audio_device
  id: parameter
  parameters:
    label: Audio device
    type: str
    value: '"plughw:3,0,0"'
  states: {}
- name: tx_audio_device
  id: parameter
  parameters:
    label: Audio device
    type: str
    value: '"plughw:3,0,1"'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:pluto.local
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_xx_0, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_rail_ff_0, '0', band_pass_filter_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', qtgui_sink_x_1, '0']
- [band_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_mute_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_mute_xx_0, '0', low_pass_filter_1, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_1, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
